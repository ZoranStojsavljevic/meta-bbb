EXTRA_OECONF:append = " --enable-bundled=yes"
