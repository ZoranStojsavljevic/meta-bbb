### Skip all QA checks (not recommended for production)
INSANE_SKIP:${PN} += "all"
