KBUILD_DEFCONFIG:beaglebone = "omap2plus_defconfig"
